File: Rapide7seg/Rapide7seg.sch (EAGLE design)
At the start: 55 parts, among them IC1 MEGA8-P, J1 AVR_SPI_PRG_6PTH

Commit message: Minor changes
Connections:
- net VCC: now also JPVCC.2
