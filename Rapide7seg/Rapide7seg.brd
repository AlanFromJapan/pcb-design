File: Rapide7seg/Rapide7seg.brd (EAGLE design)
At the start: 50 x 50 mm, 55 parts, among them IC1 MEGA8-P, J1 AVR_SPI_PRG_6PTH

Commit message: Minor changes
Connections:
- net VCC: now also JPVCC.2
